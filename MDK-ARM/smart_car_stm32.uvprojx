# Keil uVision project smart_car_stm32.uvprojx, settings and files
target smart_car_stm32 (6210000::V6.21::ARMCLANG)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: smart_car_stm32 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H743xx
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../hardware/BEEP;../hardware/KEY;../hardware/LCD;../hardware/AT24C02;../hardware/NTC;../hardware/Encoder;../hardware/Icar;../hardware/MOTOR;../hardware/PID;../hardware/SERVO;../hardware/uart_inspector;../hardware/USB;../USB_Log;../USB_Log/Core/Inc;../USB_Log/CDC/Inc
  asm include: ;../USB_Log;../USB_Log/Core/Inc;../USB_Log/CDC/Inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ../Core/Src/: rt1064_reference.c rt1064_pid_reference.c vehicle_display.c vehicle_core.c servo_control.c motor_pwm.c vehicle_ports.c vehicle_app.c comm_uart7.c
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dac.c dma.c i2c.c memorymap.c spi.c tim.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group BEEP
    ../hardware/BEEP/: tone.c
  group KEY
    ../hardware/KEY/: key.c
  group LCD
    ../hardware/LCD/: LCD_o.c
  group AT24C02
    ../hardware/AT24C02/: AT24C02.c
  group NTC
    ../hardware/NTC/: ntc.c
  group USB CDC Log
    ../USB_Log/: usb_log.c usbd_conf.c usbd_desc.c
    ../USB_Log/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../USB_Log/CDC/Src/: usbd_cdc.c
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c
software components: CMSIS:CORE 6.0.0
